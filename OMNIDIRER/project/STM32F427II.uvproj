# Keil uVision project STM32F427II.uvproj, settings and files
target OmniDir (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F427II STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,__FPU_USED=1,__FPU_PRESENT=1
  c include: ..\app;..\app\Cfg;..\app\Protocol;..\app\RMLib;..\bsp\Board;..\bsp\CMSIS;..\bsp\OS;..\bsp\ST\inc;..\bsp\Board;..\task;..\..\UCOSIII\uC-CPU;..\..\UCOSIII\uC-LIB;..\..\UCOSIII\uC-Cfg;..\..\OMNIDIRER\bsp\Board\uC-LIB;..\..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\\UCOSIII\uCOS-III\Source;..\..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../app/: app.cpp
  group Bsp
    ../bsp/Board/: bsp_lcd.cpp bsp_led.c bsp.cpp bsp.h bsp_int.c
    ../bsp/OS/: bsp_os.c
  group CMSIS
    ../bsp/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group STLib
    ../bsp/ST/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uC/CFG
    ../../UCOSIII/uC-CFG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uC/CPU
    ../../../STM32F427II/UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../../UCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../UCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOSIII-Ports
    ../../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c
  group uCOSIII-Source
    ../../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group Task
    ../task/: AppTaskCanBus.cpp AppTaskCtrl.cpp AppTaskImu.cpp AppTaskIO.cpp AppTaskRemote.cpp AppTaskSupervise.cpp
  group RMLib
    ../app/RMLib/: Ramp.cpp RM_Movement.cpp RM_Movement.h RM_Type.h PID_Regulator.cpp common.h
  group System
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/usart/: usart.c
